DATAS SEGMENT
     TIPS DB 'INPUT 1/2/3:',0DH,0AH,'$'
     CRLF DB 0DH,0AH,'$'
     NAM DB 'CKWU',0DH,0AH,'$'
     NUM DB '18029100040',0DH,0AH,'$'
DATAS ENDS

STACKS SEGMENT STACK
    DB 256 DUP(?)
STACKS ENDS

CODES SEGMENT
    ASSUME CS:CODES,DS:DATAS,SS:STACKS
START:
    MOV AX,DATAS
    MOV DS,AX
INPUT:
	LEA DX,TIPS
    MOV AH,09H
    INT 21H
	MOV AH,01H
	INT 21H
	LEA DX,CRLF
	MOV AH,09H
	INT 21H   
	CMP AL,'1'
	JE DISPNAME
	CMP AL,'2'
	JE DISPNUM
	CMP AL,'3'
	JE DONE
	JMP INPUT
DISPNAME:
	LEA DX,NAM
	MOV AH,09H
	INT 21H
	JMP DONE
DISPNUM:
	LEA DX,NUM
	MOV AH,09H
	INT 21H
DONE:
    MOV AH,4CH
    INT 21H
CODES ENDS
    END START
