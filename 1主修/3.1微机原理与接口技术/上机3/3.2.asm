DATAS SEGMENT
	ARRAY DB 1,2,3,4,5,6,7,8,9,-10,11,-12,13,14,15,16,17,18,19,20
	ARRAYP DB 20 DUP(?)
	ARRAYN DB 20 DUP(?)
    ;此处输入数据段代码  
DATAS ENDS

STACKS SEGMENT
    ;此处输入堆栈段代码
STACKS ENDS

CODES SEGMENT
    ASSUME CS:CODES,DS:DATAS,SS:STACKS
    
DISPALD PROC NEAR
	PUSH AX
	PUSH CX
	PUSH DX
	XOR AH,AH
	MOV CL,100
	DIV CL
	PUSH AX
	MOV DL,30H
	ADD DL,AL
	MOV AH,2
	;INT 21H
	
	POP AX
	MOV AL,AH
	XOR AH,AH
	MOV CL,10
	DIV CL
	PUSH AX
	MOV DL,30H
	ADD DL,AL
	MOV AH,2
	INT 21H
	
	POP AX
	MOV DL,30H
	ADD DL,AH
	MOV AH,2
	INT 21H
	POP DX
	POP CX
	POP AX
	RET
DISPALD ENDP


START:
    MOV AX,DATAS
    MOV DS,AX
    
    MOV CX,20
    XOR DX,DX
    LEA SI,ARRAY
    LEA DI,ARRAYP
    LEA BX,ARRAYN
    
L1:
	MOV AL,[SI]
	AND AL,AL
	JS L2
	MOV [DI],AL
	INC DI
	INC DL
	JMP L3
	
L2:
	MOV [BX],AL
	INC BX
	INC DH
	
L3:
	INC SI
	LOOP L1
	MOV AL,DL
	CALL DISPALD
	
	MOV DL,10
	MOV AH,2
	INT 21H
	
	
	MOV AL,DH
	CALL DISPALD
    
    ;此处输入代码段代码
    MOV AH,4CH
    INT 21H
CODES ENDS
    END START
