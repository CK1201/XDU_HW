DATAS SEGMENT
	OPERAND DW 10
	NUMBER DB 48,?,7 DUP('$')
    ;此处输入数据段代码  
DATAS ENDS

STACKS SEGMENT
    ;此处输入堆栈段代码
STACKS ENDS

CODES SEGMENT
    ASSUME CS:CODES,DS:DATAS,SS:STACKS
START:
    MOV AX,DATAS
    MOV DS,AX
    
    LEA DX,NUMBER
    LEA SI,NUMBER
    MOV AH,0AH
    INT 21H
    
    MOV CX,0
    MOV BYTE PTR CL,[SI+1]
    INC SI
    ADD SI,CX
    MOV DI,0
    MOV BX,1
    
S0:
	MOV AX,[SI]
	AND AX,00FFH
	SUB AX,30H
	MUL BX
	ADD DI,AX
	MOV AX,BX
	MUL OPERAND
	MOV BX,AX
	SUB SI,1
	LOOP S0
	
	MOV DL,10
	MOV AH,02H
	INT 21H
	
	MOV AX,DI
	MOV CX,4
	
S1:
	ROL DI,1
	ROL DI,1
	ROL DI,1
	ROL DI,1
	MOV DX,DI
	AND DX,000FH
	
	CMP DX,9
	JNG DIGIT
	
ALPHA:
	ADD DX,37H
DIGIT:
	ADD DX,30H
	
	MOV AH,02H
	INT 21H
	LOOP S1
    
    MOV AH,4CH
    INT 21H
CODES ENDS
    END START
